.subckt schematic 
.ends schematic
